# Keil uVision project ROV.uvprojx, settings and files
target ROV (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ROV +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hardware;../System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../System/: Delay.c Delay.h usart1.c usart2.c usart2.h usart1.h
    ../Hardware/: Queue.c Queue.h interval_task_scheduler.c interval_task_scheduler.h dma_circular_queue.c dma_circular_queue.h singly_list.c singly_list.h tools.c tools.h task_scheduling.c task_scheduling.h list_interface.c list_interface.h
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Hardware/: PID.c PID.h MS5837.h MS5837.c motor.h motor.c LED.h LED.c JY901.h JY901.c control.h control.c I2C1.c I2C1.h command.c command.h board.h board.c protocol.c protocol.h servo.c servo.h
  group TIme_Task_Handle
    ../Hardware/: sys.c sys.h task.c task.h
software components: CMSIS:CORE 6.1.0
